# Keil uVision project stair_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: stair_light +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source
  group source
    ./source/: delay.c interrupt_service.c lcd1602.c main.c mcu.c proj_lib.c
